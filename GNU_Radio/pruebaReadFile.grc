options:
  parameters:
    author: ASUS
    generate_options: qt_gui
    id: pruebaReadFile
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: analog_wfm_rcv
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audio_decim
    quad_rate: samp_rate
  states: {}
- name: audio_decim
  id: parameter
  parameters:
    label: Sample Rate
    short_id: s
    type: eng_float
    value: '23'
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    device_name: audio_output
    samp_rate: int(samp_rate/audio_decim)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: D:\Temporal\GNU_Radio\v0\salidaFiltro
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '104100000'
    fftsize: '512'
    grid: 'True'
    gui_hint: 2,0,2,4
    name: ''
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_wfm_rcv, '0', blocks_multiply_const_vxx, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx, '0', audio_sink, '0']
- [blocks_throttle_0, '0', analog_wfm_rcv, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
