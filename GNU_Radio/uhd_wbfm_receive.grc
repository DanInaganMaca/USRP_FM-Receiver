options:
  parameters:
    author: Example
    category: Custom
    description: WBFM Receive
    generate_options: qt_gui
    id: uhd_wbfm_receive
    output_language: python
    title: UHD WBFM Receive
  states: {}

blocks:
- name: audio_decim
  id: variable
  parameters:
    value: '23'
  states: {}
- name: fine
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,2
    label: Fine Freq (MHz)
    orient: Qt.Horizontal
    start: '-.1'
    step: '.01'
    stop: '.1'
    value: '0'
  states: {}
- name: tun_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: UHD Freq (MHz)
    orient: Qt.Horizontal
    start: '87.9'
    step: '1'
    stop: '108.1'
    value: freq/1e6
  states: {}
- name: tun_gain
  id: variable_qtgui_range
  parameters:
    label: UHD Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '20'
    value: '10'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0, 1, 4
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: analog_wfm_rcv
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audio_decim
    quad_rate: samp_rate
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    device_name: audio_output
    samp_rate: int(samp_rate/audio_decim)
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: D:\Temporal\GNU_Radio\salidaUSRP
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: D:\Temporal\GNU_Radio\salidaFiltro
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_multiply_const_vxx
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: D:\Temporal\GNU_Radio\wavFile.wav
    samp_rate: int(samp_rate/audio_decim)
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Default Frequency
    short_id: f
    type: eng_float
    value: '104100000'
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Default Gain
    short_id: g
    type: eng_float
    value: '0'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 115e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 30e3
    win: firdes.WIN_HANN
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: (tun_freq+fine)*1e6
    fftsize: '512'
    grid: 'True'
    gui_hint: 2,0,2,4
    name: ''
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: s
    type: eng_float
    value: '1024000'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: (tun_freq+fine)*1e6
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: address
    dev_args: '""'
    gain0: tun_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv, '0', blocks_multiply_const_vxx, '0']
- [blocks_multiply_const_vxx, '0', audio_sink, '0']
- [blocks_multiply_const_vxx, '0', blocks_wavfile_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv, '0']
- [low_pass_filter_0, '0', blocks_file_sink_1, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
